# Keil uVision project MCT499_Firmware.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MCT499_Firmware
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: Clock_Setting.c BT_Control.c Print_Num.c RB_Protocol.c TEST_BT_FW.c TimerA0.c GlobalVariables.c HandleIncEn.c TimerA1.c
    ./PORTs/: PORT_A.c PORT_B.c PORT_C.c PORT_D.c PORT_E.c PORT_F.c PORT_H.c PORT_K.c PORT_N.c PORT_P.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
